DISTRO_FEATURES:remove = "x11"
PACKAGECONFIG:remove = "x11"